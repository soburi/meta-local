## files/wic/xen-image-minimal.qemuarm64.wks
```
part / --source rootfs --ondisk vda --fstype=ext4 --label root --align 1024
bootloader --ptable msdos
```
