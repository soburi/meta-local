EXTRA_OECONF_append:xen = " --enable-xen"
